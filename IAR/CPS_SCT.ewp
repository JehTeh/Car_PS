# IAR project CPS_SCT.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: RM42L432PZ TexasInstruments RM42L432PZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\HCG\source; ..\HCG\include; ..\COMMON; ..\SCT
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: CPS_SCT.srec
  ILINK.IlinkOutputFile: CPS_SCT.out
  ILINK.IlinkIcfFile: C:\Users\Jonathan\Documents\GitHub\Car_PS\HCG\source\sys_link.cmd
  ILINK.IlinkProgramEntryLabel: _c_int00
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group include
    ../HCG/include/: adc.h can.h crc.h dcc.h Device_header.h Device_RM42.h Device_types.h eqep.h esm.h fee_interface.h gio.h hal_stdtypes.h het.h htu.h lin.h MemMap.h mibspi.h pinmux.h reg_adc.h reg_can.h reg_crc.h reg_dcc.h reg_efc.h reg_eqep.h reg_esm.h reg_flash.h reg_gio.h reg_het.h reg_htu.h reg_lin.h reg_mibspi.h reg_pbist.h reg_pcr.h reg_pinmux.h reg_rti.h reg_sci.h reg_spi.h reg_stc.h reg_system.h reg_tcram.h reg_vim.h rti.h sci.h spi.h std_nhet.h sys_common.h sys_core.h sys_mpu.h sys_pcr.h sys_pmu.h sys_selftest.h sys_vim.h system.h ti_fee.h ti_fee_cfg.h ti_fee_types.h
  group SCT
    ../COMMON/: CPS_common.h
    ../SCT/: SCT_main.c SCT_main.h
  group source
    ../HCG/source/: can.c dabort.asm esm.c gio.c het.c mibspi.c notification.c pinmux.c rti.c sci.c spi.c sys_core.asm sys_intvecs.asm sys_main.c sys_mpu.asm sys_pcr.c sys_phantom.c sys_pmu.asm sys_selftest.c sys_startup.c sys_vim.c system.c
